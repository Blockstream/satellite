<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>blocksat_rx_upper_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Upper part of the Blockstream Satellite receiver with real-time graphical user interface (GUI). This flowgraph implements the decoder and the MAC layer of the receiver. It is the one that should run in the host where the FIBRE application is executed. It communicates via TCP transport (as the client) with the lower (RF frontend) part of the receiver.</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Satellite Receiver (Upper End)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>barker_code</value></param>
<param><key>value</key><value>barker_code_two_dim if (modulation == "qpsk") else barker_code_one_dim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>barker_code_one_dim</value></param>
<param><key>value</key><value>sqrt(2)*numpy.real([-1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>barker_code_two_dim</value></param>
<param><key>value</key><value>[-1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>barker_len</value></param>
<param><key>value</key><value>13</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>bpsk_const</value></param>
<param><key>const_points</key><value>[1,- 1]</value></param>
<param><key>type</key><value>bpsk</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0,1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>code_rate</value></param>
<param><key>value</key><value>1.0*dataword_len/codeword_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>codeword_len</value></param>
<param><key>value</key><value>18444</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>const_order</value></param>
<param><key>value</key><value>pow(2,constellation_obj.bits_per_symbol())</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>constellation_obj</value></param>
<param><key>value</key><value>qpsk_const if (modulation == "qpsk") else bpsk_const</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dataword_len</value></param>
<param><key>value</key><value>6144</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_barker_rep</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_codewords</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_size</value></param>
<param><key>value</key><value>codeword_len*n_codewords/int(numpy.log2(const_order))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phy_bit_rate</value></param>
<param><key>value</key><value>sym_rate* ( constellation_obj.bits_per_symbol() ) * (code_rate) * (1.-phy_preamble_overhead)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phy_preamble_overhead</value></param>
<param><key>value</key><value>1.0* preamble_size / (preamble_size + payload_size)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_size</value></param>
<param><key>value</key><value>len(preamble_syms)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_syms</value></param>
<param><key>value</key><value>numpy.matlib.repmat(barker_code, 1, n_barker_rep)[0]</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>qpsk_const</value></param>
<param><key>const_points</key><value>[1,- 1]</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0,1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>value</key><value>156250 if (modulation == "qpsk") else 312500</value></param>
</block>
<block>
<key>variable_rx_logger</key>
<param><key>id</key><value>variable_rx_logger_0</value></param>
<param><key>cfo_rec</key><value>None</value></param>
<param><key>decoder</key><value>self.framers_gr_hdlc_deframer_b_0</value></param>
<param><key>enabled_start</key><value>True</value></param>
<param><key>frame_synchronizer</key><value>None</value></param>
<param><key>value</key><value>0</value></param>
<param><key>ber_log_period</key><value>1</value></param>
<param><key>cfo_log_period</key><value>0</value></param>
<param><key>frame_sync_log_period</key><value>0</value></param>
<param><key>snr_log_period</key><value>0</value></param>
<param><key>snr_meter</key><value>None</value></param>
<param><key>samp_rate</key><value>None</value></param>
</block>
<block>
<key>blks2_tcp_source</key>
<param><key>id</key><value>blks2_tcp_source_0</value></param>
<param><key>addr</key><value>src_ip</value></param>
<param><key>server</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>port</key><value>port</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_1</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>sym_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>comment</key><value>Output single-bit char</value></param>
<param><key>k</key><value>constellation_obj.bits_per_symbol()</value></param>
</block>
<block>
<key>blocksat_protocol_sink</key>
<param><key>id</key><value>blocksat_protocol_sink_0</value></param>
<param><key>blocks_pipe</key><value>/tmp/blocksat/bitcoinfibre</value></param>
<param><key>disable_api</key><value>bool(no_api)</value></param>
<param><key>disable_blocks</key><value>bool(no_blocks)</value></param>
<param><key>protocol_version</key><value>version</value></param>
<param><key>user_pipe</key><value>/tmp/blocksat/api</value></param>
</block>
<block>
<key>blocksat_turbo_decoder</key>
<param><key>id</key><value>blocksat_turbo_decoder_0</value></param>
<param><key>n_ite</key><value>max_turbo_iterations</value></param>
<param><key>N</key><value>codeword_len</value></param>
<param><key>K</key><value>dataword_len</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>comment</key><value>QPSK/BPSK Decoder</value></param>
<param><key>constellation</key><value>constellation_obj.base()</value></param>
</block>
<block>
<key>digital_descrambler_bb</key>
<param><key>id</key><value>digital_descrambler_bb_0</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x21</value></param>
<param><key>seed</key><value>0x7F</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_0_0_0</value></param>
<param><key>map</key><value>[1,- 1]</value></param>
</block>
<block>
<key>framers_gr_hdlc_deframer_b</key>
<param><key>id</key><value>framers_gr_hdlc_deframer_b_0</value></param>
<param><key>dlci</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import *</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import numpy </value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>import numpy.matlib</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>max_turbo_iterations</value></param>
<param><key>label</key><value>maximum number of Turbo decoding iterations.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>modulation</value></param>
<param><key>label</key><value>Modulation (qpsk or bpsk)</value></param>
<param><key>short_id</key><value>m</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"qpsk"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>no_api</value></param>
<param><key>label</key><value>True to Disable Satellite API Data Output</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>no_blocks</value></param>
<param><key>label</key><value>True to Disable Bitcoin FIBRE Data Output</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port</value></param>
<param><key>label</key><value>TCP Port</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5201</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>tabs@0</value></param>
<param><key>name</key><value>"Incoming Symbols"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>comment</key><value>Bits Out</value></param>
<param><key>gui_hint</key><value>tabs@1:1,0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Demodulated Bits"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>phy_bit_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0_0</value></param>
<param><key>comment</key><value>Bytes Out</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@1:0,0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Demodulated Bytes"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>phy_bit_rate/8</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>255</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>src_ip</value></param>
<param><key>label</key><value>Source IP Address (Rx Lower IP)</value></param>
<param><key>short_id</key><value>i</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>10.0.0.1</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabs</value></param>
<param><key>label0</key><value>Symbols</value></param>
<param><key>label1</key><value>Demodulation</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>version</value></param>
<param><key>label</key><value>Blockstream Satellite Protocol Version</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<connection><source_block_id>blks2_tcp_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_1</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>digital_map_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocksat_turbo_decoder_0</source_block_id><sink_block_id>digital_descrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_descrambler_bb_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_descrambler_bb_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_descrambler_bb_0</source_block_id><sink_block_id>framers_gr_hdlc_deframer_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_0_0_0</source_block_id><sink_block_id>blocksat_turbo_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>framers_gr_hdlc_deframer_b_0</source_block_id><sink_block_id>blocksat_protocol_sink_0</sink_block_id><source_key>pdu</source_key><sink_key>async_pdu</sink_key></connection>
</flow_graph>
