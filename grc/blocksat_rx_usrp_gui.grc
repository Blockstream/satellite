<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>blocksat_rx_usrp_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Blockstream Satellite receiver for USRPs with real-time graphical user interface (GUI).</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>USRP-based Satellite Receiver</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>barker_code</value></param>
<param><key>value</key><value>barker_code_two_dim if (modulation == "qpsk") else barker_code_one_dim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>barker_code_one_dim</value></param>
<param><key>value</key><value>sqrt(2)*numpy.real([-1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>barker_code_two_dim</value></param>
<param><key>value</key><value>[-1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>barker_len</value></param>
<param><key>value</key><value>13</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ber_label</value></param>
<param><key>value</key><value>"------"</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>bpsk_const</value></param>
<param><key>const_points</key><value>[1,- 1]</value></param>
<param><key>type</key><value>bpsk</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0,1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>code_rate</value></param>
<param><key>value</key><value>1.0*dataword_len/codeword_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>coded_phy_bit_rate</value></param>
<param><key>value</key><value>uncoded_phy_bit_rate * code_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>codeword_len</value></param>
<param><key>value</key><value>int(dataword_len * (1.0/target_code_rate) + 12)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>const_order</value></param>
<param><key>value</key><value>pow(2,constellation_obj.bits_per_symbol())</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>constellation_obj</value></param>
<param><key>value</key><value>qpsk_const if (modulation == "qpsk") else bpsk_const</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_size</value></param>
<param><key>value</key><value>codeword_len*n_codewords/int(numpy.log2(const_order))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dataword_len</value></param>
<param><key>value</key><value>6144</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>value</key><value>0.2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fll_pull_in_range</value></param>
<param><key>value</key><value>2 * sym_rate * (1 + 1.5*excess_bw)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_size</value></param>
<param><key>value</key><value>preamble_size + payload_size</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fs_label</value></param>
<param><key>value</key><value>"SEARCHING"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_barker_rep</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_codewords</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_rrc_taps</value></param>
<param><key>value</key><value>rrc_delay * int(sps * pcs_n_filters)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_tracking_seqs</value></param>
<param><key>value</key><value>0 if tracking_interval == 0 else floor((data_size - 1) / tracking_interval)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_size</value></param>
<param><key>value</key><value>data_size + tracking_size</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phy_overhead</value></param>
<param><key>value</key><value>float(preamble_size + tracking_size) / frame_size</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_size</value></param>
<param><key>value</key><value>len(preamble_syms)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_syms</value></param>
<param><key>value</key><value>numpy.matlib.repmat(barker_code, 1, n_barker_rep)[0]</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>qpsk_const</value></param>
<param><key>const_points</key><value>[1,- 1]</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0,1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>raw_phy_bit_rate</value></param>
<param><key>value</key><value>sym_rate* ( constellation_obj.bits_per_symbol() )</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>rf_freq_qtgui_label_0</value></param>
<param><key>value</key><value>freq</value></param>
<param><key>gui_hint</key><value>tabs@2</value></param>
<param><key>label</key><value>Current RF Center Frequency (Hz)</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_delay</value></param>
<param><key>value</key><value>int(round(-44*excess_bw + 33))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(pcs_n_filters, pcs_n_filters * sps, 1.0, excess_bw, n_rrc_taps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>sym_rate * sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>scan_range</value></param>
<param><key>value</key><value>round(n_scan_iterations * fll_pull_in_range) if scan_mode else 0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>target_code_rate</value></param>
<param><key>value</key><value>1.0/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tracking_interval</value></param>
<param><key>value</key><value>1440</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tracking_size</value></param>
<param><key>value</key><value>int(n_tracking_seqs * len(tracking_syms))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tracking_syms</value></param>
<param><key>value</key><value>tracking_syms_two_dim if (modulation == "qpsk") else tracking_syms_one_dim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tracking_syms_one_dim</value></param>
<param><key>value</key><value>[(-1 + 0j), (-1 + 0j), (-1 + 0j), (-1 + 0j), (-1 + 0j), (+1 + 0j), (-1 + 0j), (+1 + 0j), (+1 + 0j), (+1 + 0j), (-1 + 0j), (-1 + 0j), (-1 + 0j), (+1 + 0j), (+1 + 0j), (-1 + 0j), (+1 + 0j), (+1 + 0j), (-1 + 0j), (-1 + 0j), (+1 + 0j), (-1 + 0j), (-1 + 0j), (+1 + 0j), (-1 + 0j), (-1 + 0j), (-1 + 0j), (-1 + 0j), (+1 + 0j), (-1 + 0j), (+1 + 0j), (-1 + 0j)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tracking_syms_two_dim</value></param>
<param><key>value</key><value>[ (1.0/sqrt(2))*x for x in [(-1 + 1j), (-1 + 1j), (-1 + 1j), (-1 + 1j), (-1 + 1j), (+1 - 1j), (-1 + 1j), (+1 - 1j), (+1 - 1j), (+1 - 1j), (-1 + 1j), (-1 + 1j), (-1 + 1j), (+1 - 1j), (+1 - 1j), (-1 + 1j), (+1 - 1j), (+1 - 1j), (-1 + 1j), (-1 + 1j), (+1 - 1j), (-1 + 1j), (-1 + 1j), (+1 - 1j), (-1 + 1j), (-1 + 1j), (-1 + 1j), (-1 + 1j), (+1 - 1j), (-1 + 1j), (+1 - 1j), (-1 + 1j)]]</value></param>
</block>
<block>
<key>variable_tuning_control_def</key>
<param><key>id</key><value>tuning_control</value></param>
<param><key>cfo_rec</key><value>None</value></param>
<param><key>fll</key><value>self.digital_fll_band_edge_cc_1</value></param>
<param><key>frame_synchronizer</key><value>self.frame_synchronizer_0.blocksat_frame_sync_fast_0</value></param>
<param><key>freq_gui_label</key><value>self.rf_freq_qtgui_label_0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>logger</key><value>self.variable_rx_logger_0</value></param>
<param><key>nco</key><value>None</value></param>
<param><key>n_steps</key><value>n_scan_iterations</value></param>
<param><key>poll_interval</key><value>1.0/cfo_poll_rate</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>scan_interval</key><value>scan_interval</value></param>
<param><key>scan_range</key><value>scan_range</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>uncoded_phy_bit_rate</value></param>
<param><key>value</key><value>sym_rate* ( constellation_obj.bits_per_symbol() ) * (1.-phy_overhead)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_addr</value></param>
<param><key>value</key><value>ip</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_antenna</value></param>
<param><key>value</key><value>usrp_antenna_lut[antenna] if antenna in usrp_antenna_lut else None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_antenna_lut</value></param>
<param><key>value</key><value>{ 0 : "TX/RX", 1: "RX2" }</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_overview_stats</value></param>
<param><key>value</key><value>" " + ber_label + "\n " +  fs_label</value></param>
<param><key>gui_hint</key><value>tabs@0:3,0,1,1</value></param>
<param><key>label</key><value>"Bit Error Rate (BER): \nFrame Synchronization"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_rx_logger</key>
<param><key>id</key><value>variable_rx_logger_0</value></param>
<param><key>cfo_rec</key><value>self.digital_fll_band_edge_cc_1</value></param>
<param><key>decoder</key><value>self.framers_gr_hdlc_deframer_b_0</value></param>
<param><key>enabled_start</key><value>not scan_mode</value></param>
<param><key>frame_synchronizer</key><value>self.frame_synchronizer_0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>ber_log_period</key><value>10</value></param>
<param><key>cfo_log_period</key><value>10</value></param>
<param><key>frame_sync_log_period</key><value>10</value></param>
<param><key>snr_log_period</key><value>1</value></param>
<param><key>snr_meter</key><value>self.blocksat_mer_measurement_pre_frame_sync</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>agc_rate</value></param>
<param><key>label</key><value>the update rate of the automatic gain control (AGC) loop.</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1e-4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>antenna</value></param>
<param><key>label</key><value>USRP antenna (set \"0\" for \"TX/RX\" or \"1\" for \"RX2\")</value></param>
<param><key>short_id</key><value>a</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>int(samp_rate/10)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocksat_agc_cc</key>
<param><key>id</key><value>blocksat_agc_cc_0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>rate</key><value>agc_rate</value></param>
<param><key>reference</key><value>1.0</value></param>
</block>
<block>
<key>blocksat_da_carrier_phase_rec</key>
<param><key>id</key><value>blocksat_da_carrier_phase_rec_0_0</value></param>
<param><key>M</key><value>int(const_order)</value></param>
<param><key>damp_factor</key><value>1/sqrt(2)</value></param>
<param><key>debug_stats</key><value>bool(preamble_stats)</value></param>
<param><key>frame_len</key><value>frame_size</value></param>
<param><key>noise_bw</key><value>daloopbw</value></param>
<param><key>data_aided</key><value>False</value></param>
<param><key>preamble_syms</key><value>(1/sqrt(2))*preamble_syms</value></param>
<param><key>reset_per_frame</key><value>bool(dapr_en_reset)</value></param>
<param><key>tracking_interval</key><value>tracking_interval</value></param>
<param><key>tracking_syms</key><value>tracking_syms</value></param>
</block>
<block>
<key>blocksat_mer_measurement</key>
<param><key>id</key><value>blocksat_mer_measurement_pre_decoder</value></param>
<param><key>alpha</key><value>mer_alpha</value></param>
<param><key>M</key><value>int(const_order)</value></param>
</block>
<block>
<key>blocksat_mer_measurement</key>
<param><key>id</key><value>blocksat_mer_measurement_pre_frame_sync</value></param>
<param><key>alpha</key><value>mer_alpha</value></param>
<param><key>M</key><value>int(const_order)</value></param>
</block>
<block>
<key>blocksat_protocol_sink</key>
<param><key>id</key><value>blocksat_protocol_sink_0</value></param>
<param><key>blocks_pipe</key><value>/tmp/blocksat/bitcoinfibre</value></param>
<param><key>disable_api</key><value>bool(no_api)</value></param>
<param><key>disable_blocks</key><value>bool(no_blocks)</value></param>
<param><key>protocol_version</key><value>version</value></param>
<param><key>user_pipe</key><value>/tmp/blocksat/api</value></param>
</block>
<block>
<key>blocksat_soft_decoder_cf</key>
<param><key>id</key><value>blocksat_soft_decoder_cf_0</value></param>
<param><key>M</key><value>int(const_order)</value></param>
<param><key>N0</key><value>1.0</value></param>
</block>
<block>
<key>blocksat_turbo_decoder</key>
<param><key>id</key><value>blocksat_turbo_decoder_0</value></param>
<param><key>flip_llrs</key><value>False</value></param>
<param><key>n_ite</key><value>dec_max_iterations</value></param>
<param><key>pct_en</key><value>target_code_rate == 0.5</value></param>
<param><key>K</key><value>dataword_len</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cfo_poll_rate</value></param>
<param><key>label</key><value>CFO Poll Rate (Hz)</value></param>
<param><key>short_id</key><value>c</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>daloopbw</value></param>
<param><key>label</key><value>Data-aided Carrier Phase Recovery Loop Bandwidth</value></param>
<param><key>short_id</key><value>d</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.001</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dapr_en_reset</value></param>
<param><key>label</key><value>True to enable per-frame reset of DA phase recovery state.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dec_max_iterations</value></param>
<param><key>label</key><value>maximum number of Turbo decoding iterations.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>comment</key><value>Carrier Phase Recovery</value></param>
<param><key>w</key><value>2*pi/loopbw</value></param>
<param><key>order</key><value>2**constellation_obj.bits_per_symbol()</value></param>
</block>
<block>
<key>digital_descrambler_bb</key>
<param><key>id</key><value>digital_descrambler_bb_0</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x21</value></param>
<param><key>seed</key><value>0x7F</value></param>
</block>
<block>
<key>digital_fll_band_edge_cc</key>
<param><key>id</key><value>digital_fll_band_edge_cc_1</value></param>
<param><key>comment</key><value>Coarse Carrier Freq. Recovery</value></param>
<param><key>rolloff</key><value>excess_bw</value></param>
<param><key>w</key><value>fllbw</value></param>
<param><key>filter_size</key><value>rrc_delay * int(sps) + 1</value></param>
<param><key>samps_per_sym</key><value>sps</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>comment</key><value>Symbol Timing Recovery</value></param>
<param><key>filter_size</key><value>pcs_n_filters</value></param>
<param><key>init_phase</key><value>pcs_n_filters/2</value></param>
<param><key>loop_bw</key><value>pcsbw</value></param>
<param><key>max_dev</key><value>pcs_max_rate_dev</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>fll_d_freq_multiply_const</value></param>
<param><key>const</key><value>-(samp_rate / (2.0 * pi))</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>fll_d_phase_null_sink</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>fll_error_null_sink</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fllbw</value></param>
<param><key>label</key><value>Frequency-locked Loop Bandwidth</value></param>
<param><key>short_id</key><value>b</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.001</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_sync_verbosity</value></param>
<param><key>label</key><value>Frame Sync Verbosity</value></param>
<param><key>short_id</key><value>v</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>frame_synchronizer</key>
<param><key>id</key><value>frame_synchronizer_0</value></param>
<param><key>M</key><value>int(const_order)</value></param>
<param><key>fw_preamble</key><value>1</value></param>
<param><key>payload_size</key><value>payload_size</value></param>
<param><key>pmf_peak_threshold</key><value>fs_peak_threshold</value></param>
<param><key>fix_phase</key><value>(0 if bool(fs_no_phase_corr) else 1)</value></param>
<param><key>preamble_size</key><value>preamble_size</value></param>
<param><key>preamble_syms</key><value>preamble_syms</value></param>
<param><key>equalize</key><value>(0 if bool(fs_no_eq) else 1)</value></param>
<param><key>verbosity</key><value>frame_sync_verbosity</value></param>
</block>
<block>
<key>framers_gr_hdlc_deframer_b</key>
<param><key>id</key><value>framers_gr_hdlc_deframer_b_0</value></param>
<param><key>dlci</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>RF Center Frequency</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fs_no_eq</value></param>
<param><key>label</key><value>True to disable the single-tap equalization carried in the frame synchronizer.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fs_no_phase_corr</value></param>
<param><key>label</key><value>True to disable the phase correction carried in the frame synchronizer.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fs_peak_threshold</value></param>
<param><key>label</key><value>the preamble matched filter (PMF) peak detection threshold.</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.7</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>USRP Rx gain</value></param>
<param><key>short_id</key><value>g</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import *</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import numpy </value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>import numpy.matlib</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ip</value></param>
<param><key>label</key><value>USRP IP address</value></param>
<param><key>short_id</key><value>i</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>None</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>keep_one_in_n_pmf_peak_vs_time</value></param>
<param><key>n</key><value>frame_size</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>loopbw</value></param>
<param><key>label</key><value>Costas Loop Bandwidth</value></param>
<param><key>short_id</key><value>l</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mer_alpha</value></param>
<param><key>label</key><value>the MER measurement averaging alpha, i.e. the weight coefficient of its exponential moving average IIR filter.</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0001</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>modulation</value></param>
<param><key>label</key><value>Modulation (qpsk or bpsk)</value></param>
<param><key>short_id</key><value>m</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"bpsk"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>n_scan_iterations</value></param>
<param><key>label</key><value>Number of Frequency Scan Iterations </value></param>
<param><key>short_id</key><value>n</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>no_api</value></param>
<param><key>label</key><value>True to Disable Satellite API Data Output</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>no_blocks</value></param>
<param><key>label</key><value>True to Disable Bitcoin FIBRE Data Output</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pcs_max_rate_dev</value></param>
<param><key>label</key><value>maximum allowed rate deviation for the control loop of the polyphase symbol timing synchronizer.</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>pi/64</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pcs_n_filters</value></param>
<param><key>label</key><value>number of parallel filters in the polyphase clock sync block.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pcsbw</value></param>
<param><key>label</key><value>Polyphase Clock Sync Loop Bandwidth</value></param>
<param><key>short_id</key><value>w</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2*pi/50</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_stats</value></param>
<param><key>label</key><value>True to debug preamble MER and SER statistics.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_costas_const</value></param>
<param><key>gui_hint</key><value>tabs@4:1,0</value></param>
<param><key>name</key><value>"Costas Loop Output Symbols"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_overview</value></param>
<param><key>gui_hint</key><value>tabs@0:2,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>"Constellation"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_pfb_out_sym</value></param>
<param><key>comment</key><value>Tab 3 -&gt; PFB Out Sym</value></param>
<param><key>gui_hint</key><value>tabs@3</value></param>
<param><key>name</key><value>"Symbol Timing Recovery Output Symbols"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1</value></param>
<param><key>gui_hint</key><value>tabs@4:1,1</value></param>
<param><key>name</key><value>"DA Carrier Phase Rec Output Symbols (payload-only)"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_costas_state</value></param>
<param><key>gui_hint</key><value>tabs@4:0,0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Frequency</value></param>
<param><key>name</key><value>"Costas Loop State"</value></param>
<param><key>size</key><value>8*(preamble_size + payload_size)</value></param>
<param><key>srate</key><value>sym_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.1</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_agc_in</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabs@6</value></param>
<param><key>label1</key><value>Output</value></param>
<param><key>label2</key><value>Input</value></param>
<param><key>name</key><value>"Signal"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_fll_in_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>comment</key><value>Tab 2 -&gt; Coarse Rec In</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabs@2:0,0,1,2</value></param>
<param><key>alpha1</key><value>0.5</value></param>
<param><key>label1</key><value>Before</value></param>
<param><key>label2</key><value>After</value></param>
<param><key>name</key><value>"Spectrum Before/After Coarse Freq. Correction"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_HANN</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_overview</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabs@0:0,0,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>alpha1</key><value>0.5</value></param>
<param><key>name</key><value>"Spectrum"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_HANN</value></param>
<param><key>ymax</key><value>-20</value></param>
<param><key>ymin</key><value>-60</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_mer_pre_decoder</value></param>
<param><key>avg</key><value>0.001</value></param>
<param><key>gui_hint</key><value>tabs@0:2,3,2,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_VERT</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Input to Decoder</value></param>
<param><key>max</key><value>12</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>"Modulation Error Ratio (dB)"</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_mer_pre_fs</value></param>
<param><key>avg</key><value>0.001</value></param>
<param><key>gui_hint</key><value>tabs@0:2,2,2,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_VERT</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Input to Frame Synchronizer</value></param>
<param><key>max</key><value>12</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>"Modulation Error Ratio (dB)"</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_signal_level</value></param>
<param><key>gui_hint</key><value>tabs@0:2,1,2,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_VERT</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>RMS Value</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>"Signal Level"</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_pmf_peak_vs_time</value></param>
<param><key>gui_hint</key><value>tabs@1:1,0,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Preamble Matched Filter Peak vs. Time"</value></param>
<param><key>size</key><value>4*int(sym_rate/frame_size)</value></param>
<param><key>srate</key><value>sym_rate/frame_size</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>2</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_agc_rms_val</value></param>
<param><key>gui_hint</key><value>tabs@6</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Input RMS Value Estimate"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_fll_est_hist</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@2:1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Estimation History"</value></param>
<param><key>size</key><value>600</value></param>
<param><key>srate</key><value>10</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>Freq. Offset</value></param>
<param><key>yunit</key><value>"Hz"</value></param>
<param><key>ymax</key><value>sym_rate*(1 + 2*excess_bw)</value></param>
<param><key>ymin</key><value>-sym_rate*(1 + 2*excess_bw)</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_fll_inst_est</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@2:1,0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Freq. Offset Estimation"</value></param>
<param><key>size</key><value>int(round(samp_rate/1000))</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>Freq. Offset</value></param>
<param><key>yunit</key><value>"Hz"</value></param>
<param><key>ymax</key><value>sym_rate*(1 + 2*excess_bw)</value></param>
<param><key>ymin</key><value>-sym_rate*(1 + 2*excess_bw)</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_llrs</value></param>
<param><key>comment</key><value>Soft Decoder LLRs</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>tabs@5:0,0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Log Likelihood Ratios (LLRs)"</value></param>
<param><key>size</key><value>int(1024 * (1/code_rate))</value></param>
<param><key>srate</key><value>uncoded_phy_bit_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>10</value></param>
<param><key>ymin</key><value>-10</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>tabs@4:0,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"DA Carrier Phase Recovery Error"</value></param>
<param><key>size</key><value>(preamble_size + payload_size)*4</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>pi/2</value></param>
<param><key>ymin</key><value>-pi/2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>comment</key><value>Tab 1 -&gt; Timing Metric</value></param>
<param><key>gui_hint</key><value>tabs@1:0,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Mag Sq</value></param>
<param><key>name</key><value>"Frame Timing Metric"</value></param>
<param><key>size</key><value>preamble_size + payload_size</value></param>
<param><key>srate</key><value>sym_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>comment</key><value>Bits Out</value></param>
<param><key>gui_hint</key><value>tabs@5:1,0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Decoded Bits"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>coded_phy_bit_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>comment</key><value>Tab 1 -&gt; PMF Out</value></param>
<param><key>gui_hint</key><value>tabs@1:0,0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"Preamble Matched Filter Output"</value></param>
<param><key>size</key><value>preamble_size + payload_size</value></param>
<param><key>srate</key><value>sym_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_overview</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabs@0:0,2,1,2</value></param>
<param><key>int_max</key><value>-20</value></param>
<param><key>int_min</key><value>-50</value></param>
<param><key>name</key><value>"Spectrogram"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>scan_interval</value></param>
<param><key>label</key><value>Frequency Scan Interval (sec)</value></param>
<param><key>short_id</key><value>t</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>scan_mode</value></param>
<param><key>label</key><value>Frequency Scan Mode</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Oversampling Ratio</value></param>
<param><key>short_id</key><value>o</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabs</value></param>
<param><key>label0</key><value>Overview</value></param>
<param><key>label1</key><value>Frame Sync</value></param>
<param><key>label2</key><value>Freq. Sync</value></param>
<param><key>label3</key><value>Timing Sync</value></param>
<param><key>label4</key><value>Phase Sync</value></param>
<param><key>label5</key><value>Decoding</value></param>
<param><key>label6</key><value>Auto. Gain Control</value></param>
<param><key>num_tabs</key><value>7</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>usrp_antenna</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=" + usrp_addr</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>version</value></param>
<param><key>label</key><value>Blockstream Satellite Protocol Version</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>comment</key><value>Send to Sync Chain</value></param>
<param><key>stream_id</key><value>rx_norm_seq</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_5</value></param>
<param><key>comment</key><value>Send to Frame Synchronizer</value></param>
<param><key>stream_id</key><value>sym_pfbsync_out</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_6</value></param>
<param><key>comment</key><value>Send to Constellation Decoder</value></param>
<param><key>stream_id</key><value>payload_sym</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>rx_norm_seq</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>sym_pfbsync_out</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_5</value></param>
<param><key>comment</key><value>Payload Symbols</value></param>
<param><key>stream_id</key><value>payload_sym</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>qtgui_time_sink_fll_est_hist</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocksat_agc_cc_0</source_block_id><sink_block_id>qtgui_number_sink_signal_level</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocksat_agc_cc_0</source_block_id><sink_block_id>qtgui_time_agc_rms_val</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocksat_agc_cc_0</source_block_id><sink_block_id>qtgui_freq_sink_agc_in</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocksat_agc_cc_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocksat_da_carrier_phase_rec_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocksat_da_carrier_phase_rec_0_0</source_block_id><sink_block_id>blocksat_mer_measurement_pre_decoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocksat_da_carrier_phase_rec_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocksat_da_carrier_phase_rec_0_0</source_block_id><sink_block_id>virtual_sink_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocksat_mer_measurement_pre_decoder</source_block_id><sink_block_id>qtgui_number_sink_mer_pre_decoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocksat_mer_measurement_pre_frame_sync</source_block_id><sink_block_id>qtgui_number_sink_mer_pre_fs</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocksat_soft_decoder_cf_0</source_block_id><sink_block_id>blocksat_turbo_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocksat_soft_decoder_cf_0</source_block_id><sink_block_id>qtgui_time_sink_llrs</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocksat_turbo_decoder_0</source_block_id><sink_block_id>digital_descrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_costas_state</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>blocksat_mer_measurement_pre_frame_sync</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_const_sink_costas_const</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_const_sink_overview</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>virtual_sink_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_descrambler_bb_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_descrambler_bb_0</source_block_id><sink_block_id>framers_gr_hdlc_deframer_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_1</source_block_id><sink_block_id>fll_error_null_sink</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_1</source_block_id><sink_block_id>fll_d_freq_multiply_const</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_1</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_1</source_block_id><sink_block_id>qtgui_freq_sink_fll_in_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_1</source_block_id><sink_block_id>fll_d_phase_null_sink</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>qtgui_const_sink_pfb_out_sym</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fll_d_freq_multiply_const</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fll_d_freq_multiply_const</source_block_id><sink_block_id>qtgui_time_sink_fll_inst_est</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>frame_synchronizer_0</source_block_id><sink_block_id>blocksat_da_carrier_phase_rec_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>frame_synchronizer_0</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>frame_synchronizer_0</source_block_id><sink_block_id>keep_one_in_n_pmf_peak_vs_time</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>frame_synchronizer_0</source_block_id><sink_block_id>blocksat_da_carrier_phase_rec_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>frame_synchronizer_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>framers_gr_hdlc_deframer_b_0</source_block_id><sink_block_id>blocksat_protocol_sink_0</sink_block_id><source_key>pdu</source_key><sink_key>async_pdu</sink_key></connection>
<connection><source_block_id>keep_one_in_n_pmf_peak_vs_time</source_block_id><sink_block_id>qtgui_pmf_peak_vs_time</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocksat_agc_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_agc_in</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>digital_fll_band_edge_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>qtgui_freq_sink_fll_in_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>qtgui_freq_sink_overview</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>qtgui_waterfall_sink_overview</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>frame_synchronizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_5</source_block_id><sink_block_id>blocksat_soft_decoder_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
