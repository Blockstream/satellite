<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rt_initial_tuning</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_ldpc_H_matrix_def</key>
<param><key>id</key><value>H</value></param>
<param><key>filename</key><value>ldpc_mtx_file</value></param>
<param><key>gap</key><value>21</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>barker_code</value></param>
<param><key>value</key><value>barker_code_two_dim if (const_choice == "qpsk") else barker_code_one_dim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>barker_code_one_dim</value></param>
<param><key>value</key><value>sqrt(2)*numpy.real([-1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>barker_code_two_dim</value></param>
<param><key>value</key><value>[-1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>barker_len</value></param>
<param><key>value</key><value>13</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>bpsk_const</value></param>
<param><key>const_points</key><value>[1,- 1]</value></param>
<param><key>type</key><value>bpsk</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0,1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>codeword_len</value></param>
<param><key>value</key><value>18444</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>const_choice</value></param>
<param><key>value</key><value>"qpsk"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>const_order</value></param>
<param><key>value</key><value>pow(2,constellation.bits_per_symbol())</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>constellation</value></param>
<param><key>value</key><value>qpsk_const if (const_choice=="qpsk") else bpsk_const</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dataword_len</value></param>
<param><key>value</key><value>6144</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dec_factor</value></param>
<param><key>value</key><value>ceil(dsp_rate/target_samp_rate)</value></param>
</block>
<block>
<key>variable_ldpc_bit_flip_decoder_def</key>
<param><key>id</key><value>dec_ldpc</value></param>
<param><key>matrix_object</key><value>H</value></param>
<param><key>max_iterations</key><value>50</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable_ldpc_decoder_def</key>
<param><key>id</key><value>dec_ldpc2</value></param>
<param><key>file</key><value>ldpc_mtx_file</value></param>
<param><key>max_iter</key><value>5</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>sigma</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dsp_rate</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>even_dec_factor</value></param>
<param><key>value</key><value>dec_factor if (dec_factor % 1 == 1) else (dec_factor+1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>value</key><value>0.25</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>freq_t</value></param>
<param><key>block_id</key><value>tuning_control</value></param>
<param><key>function_args</key><value>self.frame_synchronizer_0.mods_frame_sync_fast_0.get_avg_timing_metric()</value></param>
<param><key>function_name</key><value>get_next_freq</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ldpc_mtx_file</value></param>
<param><key>value</key><value>gr.prefix() + "/share/gnuradio/fec/ldpc/n_0512_k_0130_gap_21.alist"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_barker_rep</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_codewords</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_rrc_taps</value></param>
<param><key>value</key><value>rrc_delay * int(sps*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_size</value></param>
<param><key>value</key><value>codeword_len*n_codewords/int(numpy.log2(const_order))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pmf_peak_threshold</value></param>
<param><key>value</key><value>0.7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_size</value></param>
<param><key>value</key><value>len(preamble_syms)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_syms</value></param>
<param><key>value</key><value>numpy.matlib.repmat(barker_code, 1, n_barker_rep)[0]</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>qpsk_const</value></param>
<param><key>const_points</key><value>[1,- 1]</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0,1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_center_freq</value></param>
<param><key>value</key><value>1428.4309e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_delay</value></param>
<param><key>value</key><value>int(round(-44*excess_bw + 33))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts*sps, 1.0, excess_bw, n_rrc_taps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>dsp_rate/even_dec_factor</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>scrambler_length</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>scrambler_poly</value></param>
<param><key>value</key><value>0x21</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>value</key><value>samp_rate / sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>target_samp_rate</value></param>
<param><key>value</key><value>sps*(200e3/(1 + excess_bw))</value></param>
</block>
<block>
<key>variable_tuning_control_def</key>
<param><key>id</key><value>tuning_control</value></param>
<param><key>freq_step</key><value>10000</value></param>
<param><key>max_freq</key><value>200000</value></param>
<param><key>min_freq</key><value>-200000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_rx_addr</value></param>
<param><key>value</key><value>"192.168.10.2"</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_1</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>comment</key><value>Automatic Gain Control</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>comment</key><value>Normalize the PMF
(Preamble should be
of unit energy syms)</value></param>
<param><key>const</key><value>1.0/(preamble_size*sqrt(2))</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_1</value></param>
<param><key>comment</key><value>Normalize the PMF</value></param>
<param><key>const</key><value>1.0/sqrt(2)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_rms_xx</key>
<param><key>id</key><value>blocks_rms_xx_1</value></param>
<param><key>alpha</key><value>0.0001</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>2*pi/800</value></param>
<param><key>order</key><value>2**constellation.bits_per_symbol()</value></param>
</block>
<block>
<key>digital_fll_band_edge_cc</key>
<param><key>id</key><value>digital_fll_band_edge_cc_1</value></param>
<param><key>rolloff</key><value>excess_bw</value></param>
<param><key>w</key><value>1e-4</value></param>
<param><key>filter_size</key><value>rrc_delay * int(sps) + 1</value></param>
<param><key>samps_per_sym</key><value>sps</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>2*pi/50</value></param>
<param><key>max_dev</key><value>pi/8</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_sync_verbosity</value></param>
<param><key>label</key><value>Frame Sync Verbosity</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import *</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import numpy </value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>import numpy.matlib</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>comment</key><value>Preamble Matched Filter (PMF)</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value> numpy.flipud(numpy.conj(preamble_syms))</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0</value></param>
<param><key>comment</key><value>Preamble Matched Filter (PMF)</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value> numpy.ones(n_barker_rep*barker_len)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>mods_frame_sync_fast</key>
<param><key>id</key><value>mods_frame_sync_fast_0</value></param>
<param><key>const_order</key><value>int(const_order)</value></param>
<param><key>equalize</key><value>1</value></param>
<param><key>fix_phase</key><value>1</value></param>
<param><key>fw_preamble</key><value>1</value></param>
<param><key>payload_len</key><value>payload_size</value></param>
<param><key>preamble_len</key><value>preamble_size</value></param>
<param><key>treshold</key><value>pmf_peak_threshold</value></param>
<param><key>verbosity</key><value>frame_sync_verbosity</value></param>
</block>
<block>
<key>mods_mer_measurement</key>
<param><key>id</key><value>mods_mer_measurement_0</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>M</key><value>int(const_order)</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_costas_const</value></param>
<param><key>gui_hint</key><value>tabs@4:1,0</value></param>
<param><key>name</key><value>"Costas Loop Output Symbols"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_pfb_out_sym</value></param>
<param><key>comment</key><value>Tab 3 -&gt; PFB Out Sym</value></param>
<param><key>gui_hint</key><value>tabs@3</value></param>
<param><key>name</key><value>"Symbol Timing Recovery Output Symbols"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1</value></param>
<param><key>gui_hint</key><value>tabs@4:1,1</value></param>
<param><key>name</key><value>"DA Carrier Phase Rec Output Symbols (payload-only)"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_costas_state</value></param>
<param><key>gui_hint</key><value>tabs@4:0,0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Costas Loop State"</value></param>
<param><key>size</key><value>1024*4</value></param>
<param><key>srate</key><value>sym_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_fll_state</value></param>
<param><key>comment</key><value>Tab 2 -&gt; FLL State</value></param>
<param><key>gui_hint</key><value>tabs@2:1,0,1,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>FLL Freq (PI Output)</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>FLL Phase Accum</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>FLL Error</value></param>
<param><key>name</key><value>"FLL State"</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>8192</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_agc_in</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabs@6</value></param>
<param><key>name</key><value>"Input Signal"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_fll_in</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>comment</key><value>Tab 2 -&gt; FLL In</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabs@2:0,0</value></param>
<param><key>name</key><value>"Frequency-Locked Loop (FLL) Input"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_fll_in_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>comment</key><value>Tab 2 -&gt; FLL Output</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabs@2:0,1</value></param>
<param><key>name</key><value>"Frequency-Locked Loop (FLL) Output"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_mer</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>tabs@0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>sym_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>Modulation Error Ratio (dB)</value></param>
<param><key>ymax</key><value>100</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_pmf_out</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>comment</key><value>Tab 1 -&gt; PMF Out</value></param>
<param><key>gui_hint</key><value>tabs@1:0,0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"Preamble Matched Filter (PMF) Output"</value></param>
<param><key>size</key><value>preamble_size + payload_size</value></param>
<param><key>srate</key><value>sym_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ylabel</key><value>Re/Im Amplitudes</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_pmf_peak_vs_time</value></param>
<param><key>gui_hint</key><value>tabs@1:1,0,1,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Preamble Matched Filter Peak vs. Time"</value></param>
<param><key>size</key><value>8*(preamble_size + payload_size)</value></param>
<param><key>srate</key><value>sym_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.1</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_pmf_timing_metric</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>comment</key><value>Tab 1 -&gt; Timing Metric</value></param>
<param><key>gui_hint</key><value>tabs@1:0,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Mag Sq</value></param>
<param><key>name</key><value>"Frame Timing Metric"</value></param>
<param><key>size</key><value>preamble_size + payload_size</value></param>
<param><key>srate</key><value>sym_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_agc_rms_val</value></param>
<param><key>gui_hint</key><value>tabs@6</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Input RMS Value Estimate"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>rf_center_freq + freq_t</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>40</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabs</value></param>
<param><key>label0</key><value>SNR</value></param>
<param><key>label1</key><value>Frame Sync</value></param>
<param><key>label2</key><value>Freq. Sync</value></param>
<param><key>label3</key><value>Timing Sync</value></param>
<param><key>label4</key><value>Phase Sync</value></param>
<param><key>label5</key><value>Demodulation</value></param>
<param><key>label6</key><value>Auto. Gain Control</value></param>
<param><key>num_tabs</key><value>7</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>rf_center_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.10.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>comment</key><value>Send to FLL</value></param>
<param><key>stream_id</key><value>rx_norm_seq</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2_0</value></param>
<param><key>stream_id</key><value>rx_seq</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_5</value></param>
<param><key>comment</key><value>Send to Frame Synchronizer</value></param>
<param><key>stream_id</key><value>sym_pfbsync_out</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>rx_seq</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>rx_norm_seq</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>sym_pfbsync_out</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_1</source_block_id><sink_block_id>blocks_divide_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>mods_frame_sync_fast_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>qtgui_pmf_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_1</source_block_id><sink_block_id>blocks_complex_to_mag_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>mods_frame_sync_fast_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_pmf_timing_metric</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_1</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_1</source_block_id><sink_block_id>qtgui_time_agc_rms_val</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_costas_state</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>mods_mer_measurement_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_const_sink_costas_const</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>virtual_sink_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_1</source_block_id><sink_block_id>qtgui_fll_state</sink_block_id><source_key>3</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_1</source_block_id><sink_block_id>qtgui_fll_state</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_1</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_1</source_block_id><sink_block_id>qtgui_freq_sink_fll_in_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_1</source_block_id><sink_block_id>qtgui_fll_state</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>qtgui_const_sink_pfb_out_sym</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_divide_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>mods_frame_sync_fast_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mods_frame_sync_fast_0</source_block_id><sink_block_id>qtgui_pmf_peak_vs_time</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mods_frame_sync_fast_0</source_block_id><sink_block_id>qtgui_const_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mods_mer_measurement_0</source_block_id><sink_block_id>qtgui_mer</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_agc_in</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>virtual_sink_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>virtual_sink_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_rms_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>digital_fll_band_edge_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>qtgui_freq_sink_fll_in</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>mods_frame_sync_fast_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
